# Keil uVision project robo_template.uvprojx, settings and files
target robo_template (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: robo_template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__TARGET_FPU_VFP,DEBUG_MODE,ENGINEER
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Libraries/Scheduler;../Libraries/Helper;../Libraries/InertialSensor;../Libraries/Math;../Libraries/Param;../Libraries/AHRS;../Libraries/RCProtocol;../Libraries/RefereeSystem;../Libraries/PID;../Libraries/Motor;../Libraries/CanDevice;../Libraries/Message;../Modules/Types;../Libraries/Error;../Modules/Common/CAN;../Modules/RoboMaster/Core;../Modules/RoboMaster/Motor;../Modules/Common/PID;../Modules/MyActuator;../Libraries/UART;../Vehicles/Engineer;../Modules/DaMiao;../Modules/BenMo;../Modules/LK-Tech
  memory RVCT4: ROM 0x8000000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp gpio.c adc.c can.c dma.c i2c.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Libraries/AHRS
    ../Libraries/AHRS/: AHRS.cpp MahonyAHRS.cpp
  group Libraries/CanDevice
    ../Libraries/CanDevice/: CanDevice.cpp
  group Libraries/Error
    ../Libraries/Error/: Error.cpp
  group Libraries/Helper
    ../Libraries/Helper/: Helper.cpp
  group Libraries/InertialSensor
    ../Libraries/InertialSensor/: InertialSensor.cpp InertialSensor_BMI088.cpp InertialSensor_Backend.cpp
  group Libraries/Math
    ../Libraries/Math/: CommonMath.cpp CmsisCompatibility.cpp Filters.cpp Matrix3.cpp Quaternion.cpp Rotation.cpp Translation.cpp Vector2.cpp Vector3.cpp
  group Libraries/Motor
    ../Libraries/Motor/: Motor.cpp Motor_RM.cpp Motor_Backend.cpp Motor_MC.cpp Motor_MC.h Motor_DM.cpp Motor_DM.h Motor_M15.cpp Motor_M15.h Motor_MG.cpp Motor_MG.h
  group Libraries/Param
    ../Libraries/Param/: Flash.cpp
  group Libraries/PID
    ../Libraries/PID/: PID_Controller.cpp
  group Libraries/RCProtocol
    ../Libraries/RCProtocol/: RCProtocol.cpp RCProtocol_Backend.cpp RCProtocol_DBUS.cpp
  group Libraries/RefereeSystem
    ../Libraries/RefereeSystem/: RefereeSystem_Data.cpp
  group Libraries/Scheduler
    ../Libraries/Scheduler/: Task.cpp Scheduler.cpp Scheduler_Common.cpp
  group Libraries/UART
    ../Libraries/UART/: UARTDriver.cpp
  group Modules/Common/PID
    ../Modules/Common/PID/: PIDControlTask.cpp
  group Modules/Commonr/CAN
    ../Modules/Common/CAN/: CANSendTask.cpp
  group Modules/RoboMaster/Core
    ../Modules/RoboMaster/Core/: AttitudeSolutionTask.cpp LEDControlTask.cpp SongPlayerTask.cpp
  group Modules/RoboMaster/Motor
    ../Modules/RoboMaster/Motor/: Motor_RM_Tasks.cpp
  group Modules/MyActuator
    ../Modules/MyActuator/: Motor_MC_Tasks.h Motor_MC_Tasks.cpp
  group Modules/DaMiao
    ../Modules/DaMiao/: Motor_DM_Task.cpp Motor_DM_Task.h
  group Modules/BenMo
    ../Modules/BenMo/: Motor_M15_Task.cpp Motor_M15_Task.h
  group Modules/LK-tech
    ../Modules/LK-Tech/: Motor_MG_Tasks.cpp Motor_MG_Tasks.h
  group Vehicles/Engineer/task
    ../Vehicles/Engineer/Chassis/: ChassisControlTask.h ChassisControlTask.cpp
    ../Vehicles/Engineer/ArmContorlTask/: ArmControlTask.cpp ArmControlTask.h
    ../Vehicles/Engineer/Remote/: RemoteControlTask.cpp RemoteControlTask.h
    ../Vehicles/Engineer/Gimbal/: GimbalControlTask.cpp GimbalControlTask.h
    ../Vehicles/Engineer/Robot/: Robot.cpp Robot.h Params.cpp Params.h
    ../Vehicles/Engineer/Referee/: RefereeSystemTask.cpp RefereeSystemTask.h
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
